# Keil uVision project DTU.uvprojx, settings and files
target DTU (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DTU +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: at24c02.c gpio.c main.c stmflash.c data.c stm32f10x_it.c work.c
  group SYSTEM
    ../SYSTEM/: delay.c rtc.c sys.c timer.c uart.c watchdog.c
  group CORE
    ../CORE/: core_cm3.c system_stm32f10x.c stm32f10x.h stm32f10x_conf.h startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_iwdg.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_pwr.c
